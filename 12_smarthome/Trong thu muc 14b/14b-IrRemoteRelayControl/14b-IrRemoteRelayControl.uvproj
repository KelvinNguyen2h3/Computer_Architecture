# Keil uVision project 14b-IrRemoteRelayControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 14b-IrRemoteRelayControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ../00-libfiles/: nec_ir.c nec_ir.h stdutils.h
    ./: main.c XPT2046.c
